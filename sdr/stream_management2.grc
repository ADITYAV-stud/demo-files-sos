options:
  parameters:
    generate_options: qt_gui
    id: stream_management2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: 1k
    gain: '1'
    samp_rate: 2M
    type: fir_filter_ccf
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '20'
    if_gain0: '20'
    sample_rate: 2M
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: 915M
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2M
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
